# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h IndependentKey.h IndependentKey.c NixieTube.h NixieTube.c Timer1.c Timer1.h Int0.c Int0.h IR.h IR.c Timer0.h Timer0.c Motor.c Motor.h
